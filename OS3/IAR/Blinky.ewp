# IAR project Blinky.ewp, settings and files
configuration source (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCIncludePath2: ..\; ..\..\; ..\..\..\..\BSP\YRDKRX63N; ..\..\..\..\..\Micrium\Software\uC-CPU; ..\..\..\..\..\Micrium\Software\uC-CPU\RX\IAR; ..\..\..\..\..\Micrium\Software\uC-LIB; ..\..\..\..\..\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\Micrium\Software\uCOS-III\Ports\Renesas\RX\IAR
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinky.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\BSP\Startup\RX\IAR\lnkr5f563nb.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Micrium/Software/uC-CPU
    ../../../../../Micrium/Software/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group Micrium/Software/uC-CPU/RX/IAR
    ../../../../../Micrium/Software/uC-CPU/RX/IAR/: cpu.h
  group Micrium/Software/uC-LIB
    ../../../../../Micrium/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Micrium/Software/uCOS-III/Ports/Renesas/RX/IAR
    ../../../../../Micrium/Software/uCOS-III/Ports/Renesas/RX/IAR/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group Micrium/Software/uCOS-III/Source
    ../../../../../Micrium/Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
  group Renesas/BSP/iodefines
    ../../../../BSP/iodefines/: iorx63n.h
  group Renesas/BSP/Startup/RX/IAR
    ../../../../BSP/Startup/RX/IAR/: lnkr5f563nb.icf startup_rx.s
  group Renesas/BSP/YRDKRX63N
    ../../../../BSP/YRDKRX63N/: bsp_clk.c bsp_clk.h bsp_int.c bsp_int.h bsp_led.c bsp_led.h bsp_os.c bsp_os.h bsp_uart.c bsp_uart.h
  group Renesas/YRDKRX63N/Blinky
    ../../: app_cfg.h cpu_cfg.h lib_cfg.h
  group Renesas/YRDKRX63N/Blinky/OS3
    ../: main.c os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
